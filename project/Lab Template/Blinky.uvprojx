# Keil uVision project Blinky.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: fputc_def.c main.c tm_stm32f4_lis302dl_lis3dsh.c tm_stm32f4_spi.c AS504x.c LSM9DS0.c sys.c MC339xx.c
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_tim.c
target STM32F407 Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0
